# Keil uVision project display2.uvprojx, settings and files
target display (ARM-ADS)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.3.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: display2
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Display
    ./Sources/: display.c main.c display.h
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Startup 1.0.0
